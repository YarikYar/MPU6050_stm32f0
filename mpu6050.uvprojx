# Keil uVision project mpu6050.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00004000) IRAM(0x20000000,0x00001000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: mpu6050
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: delay.c i2c.c main.c ssd1306.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
